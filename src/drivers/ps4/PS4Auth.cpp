#include "host/usbh.h"
#include "class/hid/hid.h"
#include "class/hid/hid_host.h"
#include "drivers/ps4/PS4Auth.h"
#include "drivers/ps4/PS4AuthUSBListener.h"
#include "CRC32.h"
#include "peripheralmanager.h"
#include "storagemanager.h"
#include "usbhostmanager.h"

#include "enums.pb.h"

#include "mbedtls/error.h"
#include "mbedtls/rsa.h"
#include "mbedtls/sha256.h"

#define NEW_CONFIG_MPI(name, buf, size) \
    mbedtls_mpi_uint *bytes ## name = new mbedtls_mpi_uint[size / sizeof(mbedtls_mpi_uint)]; \
    mbedtls_mpi name = { .p=bytes ## name, .s=1, .n=static_cast<unsigned short>(size / sizeof(mbedtls_mpi_uint)) }; \
    memcpy(bytes ## name, buf, size);

#define DELETE_CONFIG_MPI(name) delete[] bytes ## name;

static inline int rng(void*p_rng, unsigned char* p, size_t len) {
    (void) p_rng;
    p[0] = rand();
    return 0;
}

// --- 内嵌 PS4 认证密钥（从 GPReceiverHML BoardConfig.h 提取） ---
static const uint8_t PS4_SERIAL[16] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x01, 0x00, 0x01, 0x00, 0x25, 0x19, 0x24
};

static const uint8_t PS4_SIGNATURE[256] = {
    0x36, 0xF2, 0xB2, 0x67, 0x8B, 0x2E, 0xC1, 0x39, 0x6A, 0x55, 0x17, 0xEE, 0x9E, 0x94, 0x73, 0x6F,
    0xF8, 0x0D, 0x8D, 0x45, 0x95, 0x65, 0x66, 0x7A, 0x7D, 0x08, 0x4F, 0x93, 0x21, 0x3D, 0xD6, 0x66,
    0x7C, 0x23, 0xDC, 0xBD, 0x1C, 0xCC, 0xE7, 0x90, 0x72, 0xD0, 0xAD, 0x03, 0xFF, 0xC0, 0xF0, 0x6F,
    0x6C, 0xDA, 0x19, 0x2E, 0xDB, 0xC4, 0x43, 0xBB, 0xC7, 0x70, 0x80, 0x0E, 0xFB, 0xF5, 0x7A, 0xBC,
    0x3B, 0xE8, 0xF8, 0xD1, 0x4C, 0x07, 0x06, 0xDA, 0x0A, 0xC5, 0x98, 0x2E, 0x66, 0x12, 0x6D, 0x59,
    0x98, 0xC5, 0x63, 0x63, 0xA5, 0x5D, 0x59, 0xC8, 0x88, 0x85, 0x82, 0x2D, 0x71, 0x0C, 0x38, 0xA4,
    0x78, 0xF8, 0x1A, 0xF5, 0x8A, 0xAB, 0x2E, 0x84, 0x17, 0xB1, 0x18, 0x9C, 0xC2, 0xBE, 0x91, 0xA5,
    0x23, 0xFC, 0x83, 0xFD, 0xDA, 0xE3, 0x20, 0xA6, 0x1B, 0x80, 0x6F, 0x14, 0x59, 0x77, 0x7B, 0x51,
    0xB7, 0x9D, 0x95, 0xE0, 0xDF, 0x07, 0x3B, 0xC7, 0x3F, 0x2B, 0x8C, 0xDD, 0x2A, 0xE2, 0x09, 0x01,
    0xF5, 0xB9, 0x27, 0xB8, 0x18, 0x56, 0x38, 0xF7, 0x14, 0xA9, 0xE0, 0x7B, 0x04, 0x24, 0x3E, 0x72,
    0x8E, 0x7E, 0xC7, 0xCD, 0x54, 0x34, 0xA0, 0x05, 0xC6, 0x98, 0x7B, 0x63, 0x2C, 0x41, 0x09, 0x43,
    0x8B, 0xF2, 0x17, 0xAF, 0x6C, 0x67, 0x73, 0x21, 0xAC, 0x46, 0x14, 0x84, 0x16, 0x3A, 0xE9, 0x7D,
    0x51, 0x37, 0x0C, 0xED, 0x8C, 0xF7, 0x66, 0x15, 0xC3, 0xA3, 0x39, 0x1E, 0xF8, 0x94, 0xEB, 0xD8,
    0x17, 0x80, 0xEE, 0x85, 0xB6, 0xF1, 0xCB, 0x56, 0x10, 0xB5, 0x9D, 0x7F, 0x1B, 0x74, 0x8B, 0x8C,
    0xF3, 0x6B, 0xB9, 0x10, 0xA8, 0x92, 0xFF, 0xB9, 0xE8, 0x90, 0x2B, 0xCF, 0x4A, 0x6A, 0x18, 0x28,
    0x2C, 0x79, 0xE9, 0x96, 0xF7, 0xEA, 0x88, 0x02, 0x95, 0x9D, 0x9C, 0x39, 0x23, 0x46, 0x6A, 0x20
};

static const uint8_t PS4_RSA_N[256] = {
    0x03, 0xB1, 0xE6, 0x82, 0x14, 0x1B, 0x74, 0x93, 0x6D, 0xDA, 0x80, 0x56, 0xD6, 0xA2, 0x79, 0x66,
    0x13, 0xB1, 0x78, 0x03, 0xC4, 0x9A, 0x65, 0x95, 0x73, 0xD3, 0xF7, 0xC7, 0xFE, 0xD4, 0xAE, 0x95,
    0x0C, 0x2B, 0xF0, 0x09, 0x4D, 0xBA, 0x35, 0x29, 0xFD, 0x60, 0x2A, 0xAF, 0x58, 0x81, 0xFB, 0x69,
    0x87, 0x2A, 0x23, 0xB4, 0x43, 0xB3, 0x22, 0x88, 0x5A, 0x42, 0xBE, 0x37, 0x87, 0x85, 0x47, 0xE6,
    0x3B, 0x6F, 0xDF, 0xC8, 0x5A, 0x75, 0x6F, 0xA3, 0xCF, 0x52, 0xC9, 0xF6, 0x1F, 0x97, 0x2C, 0x80,
    0xDF, 0x09, 0x9E, 0xBB, 0x84, 0x9D, 0x3D, 0x08, 0xF9, 0x28, 0xCC, 0x2F, 0x0B, 0x84, 0x68, 0x86,
    0x88, 0x71, 0xBC, 0x4A, 0x4E, 0x95, 0x3F, 0x44, 0xF0, 0xDF, 0x0F, 0x84, 0x4E, 0x53, 0x26, 0x5D,
    0x2B, 0x2A, 0xB9, 0x91, 0xA5, 0x09, 0x17, 0x76, 0xA8, 0x28, 0xE3, 0xAA, 0xD6, 0xAD, 0x14, 0x9F,
    0x08, 0x27, 0xC2, 0x30, 0xEC, 0x4D, 0x44, 0x14, 0x1C, 0xCF, 0x58, 0x7B, 0x6F, 0xF9, 0xD8, 0x6A,
    0x87, 0x07, 0x17, 0xFF, 0xC0, 0xA2, 0x41, 0x59, 0xDF, 0x73, 0x2E, 0xD0, 0x28, 0x47, 0x71, 0x75,
    0x92, 0x04, 0x13, 0xA1, 0x18, 0xEB, 0x57, 0x6F, 0x28, 0x4A, 0x26, 0x84, 0x34, 0xC1, 0x4B, 0xC9,
    0x3E, 0x45, 0x33, 0x46, 0x7E, 0x36, 0x36, 0xB0, 0x67, 0x3D, 0x48, 0x30, 0xC1, 0x7A, 0xF0, 0x4D,
    0xC2, 0xAC, 0xF4, 0x16, 0xAE, 0x33, 0xC6, 0xC9, 0xA5, 0x39, 0x6B, 0xF2, 0xF5, 0x94, 0xC8, 0xEF,
    0xB4, 0x55, 0xFF, 0x36, 0xCB, 0xD5, 0xA2, 0xFC, 0xB9, 0x33, 0x3D, 0x25, 0xD5, 0xD9, 0xA9, 0x19,
    0xC2, 0xDB, 0xAD, 0xCE, 0xDA, 0x55, 0x00, 0x86, 0x6F, 0x6F, 0x15, 0xF9, 0x20, 0x7E, 0x28, 0x13,
    0xCD, 0xA0, 0xAA, 0xA2, 0x5E, 0xA9, 0x62, 0x30, 0x34, 0xDF, 0x10, 0x32, 0x5E, 0x43, 0xC1, 0x84
};

static const uint8_t PS4_RSA_E[4] = { 0x01, 0x00, 0x01, 0x00 };

static const uint8_t PS4_RSA_P[128] = {
    0x0D, 0xA5, 0x20, 0xCA, 0x5B, 0x53, 0x54, 0xB6, 0x0C, 0xE9, 0x1B, 0x9B, 0xE4, 0x8B, 0x86, 0x7F,
    0x54, 0xB7, 0xAF, 0xDE, 0x99, 0x52, 0xCF, 0x2B, 0x0C, 0xEA, 0x1A, 0x40, 0x66, 0xCA, 0xA9, 0xC7,
    0x9E, 0x25, 0x07, 0x52, 0x11, 0xF7, 0x7D, 0x0A, 0xEA, 0xD7, 0x32, 0x6D, 0xD4, 0x3A, 0xB3, 0x1F,
    0xB9, 0xD7, 0x33, 0x3B, 0x73, 0xCF, 0x67, 0x0D, 0xF1, 0x85, 0x3F, 0x74, 0x36, 0xE8, 0xE0, 0xE2,
    0x48, 0x96, 0x67, 0x0B, 0xB1, 0xCB, 0x4C, 0xCC, 0x12, 0x7E, 0x53, 0xCB, 0x95, 0x2A, 0xE3, 0x7A,
    0x88, 0x90, 0x16, 0x53, 0xEC, 0xAC, 0x56, 0x84, 0x1E, 0x22, 0xE3, 0x36, 0x55, 0xC2, 0xC1, 0xFB,
    0xF7, 0x65, 0x13, 0x84, 0xC2, 0xAE, 0xA4, 0x48, 0x98, 0xED, 0xD5, 0x00, 0x25, 0x0B, 0x38, 0x93,
    0xC4, 0x2D, 0x03, 0xCD, 0x72, 0x4F, 0x2F, 0x0B, 0xAC, 0x61, 0xD5, 0x99, 0x90, 0xCB, 0xC7, 0x8C
};

static const uint8_t PS4_RSA_Q[128] = {
    0x4F, 0x4A, 0x16, 0x94, 0x02, 0x55, 0x6D, 0x4F, 0xBF, 0x6B, 0xAF, 0x0A, 0xA4, 0xA7, 0x75, 0xDE,
    0xCB, 0xDF, 0xA2, 0xB6, 0xD9, 0x6B, 0x8B, 0xDC, 0x19, 0x8D, 0x21, 0x96, 0x7B, 0x51, 0x6A, 0x9A,
    0x59, 0x4C, 0x07, 0xEB, 0xB9, 0x93, 0x25, 0xD4, 0xE7, 0xFD, 0xB4, 0x4E, 0xC4, 0x4E, 0xDD, 0xDE,
    0xC4, 0x93, 0xF8, 0x87, 0x1C, 0xCC, 0xF6, 0xD4, 0xB6, 0x9E, 0xCA, 0xC7, 0xDB, 0xDA, 0xFC, 0xEE,
    0x13, 0xA6, 0x87, 0x83, 0x8F, 0x30, 0x3F, 0x09, 0xE4, 0x93, 0xCE, 0x2B, 0x1E, 0x3C, 0x3D, 0xF9,
    0x1D, 0xD3, 0x19, 0x0A, 0x42, 0x50, 0x3A, 0x05, 0x83, 0x3A, 0xFC, 0xB9, 0x7A, 0x25, 0xD9, 0x86,
    0xA5, 0xF1, 0x67, 0xB0, 0x06, 0x34, 0x57, 0xAB, 0xBC, 0xFB, 0x8B, 0x2A, 0x90, 0xFF, 0x32, 0x82,
    0x08, 0x2A, 0x83, 0x60, 0x78, 0x2C, 0x86, 0x62, 0x1C, 0xCA, 0x0D, 0xEE, 0xEE, 0xF7, 0x67, 0xF1
};

void PS4Auth::initialize() {
    if ( !available() ) {
        return;
    }

    listener = nullptr;
    ps4AuthData.dongle_ready = false;
    ps4AuthData.nonce_id = 0;
    ps4AuthData.passthrough_state = GPAuthState::auth_idle_state;
    memset(ps4AuthData.ps4_auth_buffer, 0, 1064);
    if (authType == InputModeAuthType::INPUT_MODE_AUTH_TYPE_KEYS ) {
        keyModeInitialize();
    } else if (authType == InputModeAuthType::INPUT_MODE_AUTH_TYPE_USB ) {
        listener = new PS4AuthUSBListener();
        ((PS4AuthUSBListener*)listener)->setup();
        ((PS4AuthUSBListener*)listener)->setAuthData(&ps4AuthData);
    }
}

bool PS4Auth::available() {
    if ( authType == InputModeAuthType::INPUT_MODE_AUTH_TYPE_KEYS ) {
        // 密钥已内嵌，恒可用
        return true;
    } else if ( authType == InputModeAuthType::INPUT_MODE_AUTH_TYPE_USB ) {
        return (PeripheralManager::getInstance().isUSBEnabled(0));
    }
    return false;
}

void PS4Auth::process() {
    if (authType == InputModeAuthType::INPUT_MODE_AUTH_TYPE_KEYS ) {
        keyModeProcess();
    } else if (authType == InputModeAuthType::INPUT_MODE_AUTH_TYPE_USB ) {
        ((PS4AuthUSBListener*)listener)->process(); 	// process HOST with client data
    }
}

// Init if we're in ps4 key mode
void PS4Auth::keyModeInitialize() {
    ps4AuthData.valid_rsa = false;
    NEW_CONFIG_MPI(N, PS4_RSA_N, sizeof(PS4_RSA_N))
    NEW_CONFIG_MPI(E, PS4_RSA_E, sizeof(PS4_RSA_E))
    NEW_CONFIG_MPI(P, PS4_RSA_P, sizeof(PS4_RSA_P))
    NEW_CONFIG_MPI(Q, PS4_RSA_Q, sizeof(PS4_RSA_Q))
    mbedtls_rsa_init(&ps4AuthData.rsa_context);
    mbedtls_rsa_set_padding(&ps4AuthData.rsa_context, MBEDTLS_RSA_PKCS_V21, MBEDTLS_MD_SHA256);
    if (mbedtls_rsa_import(&ps4AuthData.rsa_context, &N, &P, &Q, nullptr, &E) == 0 &&
            mbedtls_rsa_complete(&ps4AuthData.rsa_context) == 0) {
        ps4AuthData.valid_rsa = true;
    }
    DELETE_CONFIG_MPI(N)
    DELETE_CONFIG_MPI(E)
    DELETE_CONFIG_MPI(P)
    DELETE_CONFIG_MPI(Q)

    // Reset our random seed
    srand(0);
}

// Process if we are using ps4 keys
void PS4Auth::keyModeProcess() {
    // Do not run if RSA is invalid
    if (!ps4AuthData.valid_rsa) {
        return;
    }

    // Check to see if the PS4 Authentication needs work
    if ( ps4AuthData.passthrough_state == GPAuthState::send_auth_console_to_dongle ) {
        int rss_error = 0;
        uint8_t hashed_nonce[32];
        // Sign our nonce into hashed_nonce
        if ( mbedtls_sha256(ps4AuthData.ps4_auth_buffer, 256, hashed_nonce, 0) < 0 ) {
            return;
        }
        rss_error = mbedtls_rsa_rsassa_pss_sign(&ps4AuthData.rsa_context, rng, nullptr,
                MBEDTLS_MD_SHA256,
                32, hashed_nonce,
                ps4AuthData.ps4_auth_buffer);
        if ( rss_error < 0 ) {
            return; // If we could not sign with our key, return (error)
        }
        // copy the parts into our authentication buffer
        size_t offset = 256;
        memcpy(&ps4AuthData.ps4_auth_buffer[offset], PS4_SERIAL, sizeof(PS4_SERIAL));
        offset += 16;
        mbedtls_rsa_export_raw(
            &ps4AuthData.rsa_context,
            &ps4AuthData.ps4_auth_buffer[offset], 256,
            nullptr, 0,
            nullptr, 0,
            nullptr, 0,
            &ps4AuthData.ps4_auth_buffer[offset+256], 256
        );
        offset += 512;
        memcpy(&ps4AuthData.ps4_auth_buffer[offset], PS4_SIGNATURE, sizeof(PS4_SIGNATURE));
        offset += 256;
        memset(&ps4AuthData.ps4_auth_buffer[offset], 0, 24);
        ps4AuthData.passthrough_state = GPAuthState::send_auth_dongle_to_console;
    }
}

void PS4Auth::resetAuth() {
    if (authType == InputModeAuthType::INPUT_MODE_AUTH_TYPE_USB ) {
        ((PS4AuthUSBListener*)listener)->resetHostData();
    }
    ps4AuthData.passthrough_state = GPAuthState::auth_idle_state;
}
